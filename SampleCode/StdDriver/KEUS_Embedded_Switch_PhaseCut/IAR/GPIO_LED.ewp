# IAR project GPIO_LED.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini58DE series Nuvoton Mini58DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Mini58Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_LED.hex
  ILINK.IlinkOutputFile: GPIO_LED.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: GPIO_LED.bin
  group CMSIS
    ../../../../Library/Device/Nuvoton/MINI58SERIES/Source/IAR/: startup_Mini58Series.s
    ../../../../Library/Device/Nuvoton/MINI58SERIES/Source/: system_Mini58Series.c
  group Keus_E_Switch
    ../: button.c button.h keusActions.c keusActions.h keusuart.c keusuart.h phasecut.c phasecut.h
  group Library
    ../../../../Library/StdDriver/src/: clk.c pwm.c sys.c
    ../../../../Library/STDDRIVER/src/: gpio.c retarget.c timer.c uart.c
  group User
    ../: main.c
