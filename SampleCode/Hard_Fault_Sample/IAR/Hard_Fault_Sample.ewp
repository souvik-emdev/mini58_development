# IAR project Hard_Fault_Sample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Mini58DE series Nuvoton Mini58DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\Mini58Series\Include; ..\..\..\Library\StdDriver\Inc; ..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Hard_Fault_Sample.bin
  ILINK.IlinkOutputFile: Hard_Fault_Sample.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../Library/Device/Nuvoton/Mini58Series/Source/IAR/: startup_Mini58Series.s
    ../../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
