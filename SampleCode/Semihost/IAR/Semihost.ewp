# IAR project Semihost.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Mini58DE series Nuvoton Mini58DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\Library\Device\Nuvoton\Mini58Series\Include; $PROJ_DIR$..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Semihost.bin
  ILINK.IlinkOutputFile: Semihost.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../Library/Device/Nuvoton/Mini58Series/Source/IAR/: startup_Mini58Series.s
    ../../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
